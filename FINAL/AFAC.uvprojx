# Keil uVision project AFAC.uvprojx, settings and files
target Simulation (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AFAC_simulation
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Headers;..\DRIVERS;.\Sources
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MySources
    ./Sources/: main.c girouette.c girouette.h m_voiles.c m_voiles.h m_orientation.c m_orientation.h m_envoi.c m_envoi.h roulis.c roulis.h
  group MyDrivers
    ../DRIVERS/: driver_gpio.c driver_gpio.h driver_timer.c driver_timer.h driver_usart.c driver_usart.h driver_adc.c driver_adc.h Lib_Com_Periph_2022.lib MyI2C.h MySPI.h
target Reel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: AFAC_reel
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Headers;..\DRIVERS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
